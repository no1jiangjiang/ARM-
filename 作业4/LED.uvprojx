# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10x_HD
  c include: D:\mdk5\pack\Keil\STM32F1xx_DFP\2.1.0\Device\Include;D:\mdk5\pack\ARM\CMSIS\5.7.0\Device\_Template_Vendor\Vendor\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.h
software components: CMSIS:CORE 5.4.0
